# IAR project BH-1.ewp, settings and files
configuration BH-1 (ARM, debug)
  General.OGChipSelectEditMenu: STM32F373CC ST STM32F373CC
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCIncludePath2: C:\Users\DELL\source\repos\ID\heating-controller\Src; C:\Users\DELL\source\repos\ID\heating-controller\Inc; C:\Users\DELL\source\repos\ID\heating-controller\Drivers\STM32F3xx_HAL_Driver\Inc; C:\Users\DELL\source\repos\ID\heating-controller\Drivers\STM32F3xx_HAL_Driver\Src; C:\Users\DELL\source\repos\ID\heating-controller\Drivers\CMSIS\Device\ST\STM32F3xx\Include; C:\Users\DELL\source\repos\ID\heating-controller\Drivers\CMSIS\Device\ST\STM32F3xx\Source; C:\Users\DELL\source\repos\ID\heating-controller\Drivers\CMSIS\Core\Include
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: BH-1.hex
  ILINK.IlinkOutputFile: BH-1.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32f373xc.s
  group Application/User
    ../Src/: gpio.c main.c rtc.c spi.c stm32f3xx_hal_msp.c stm32f3xx_it.c tim.c usart.c
  group Application/User/Drivers/CMSIS
    ../Src/: system_stm32f3xx.c
  group Application/User/Drivers/STM32F3xx_HAL_Driver
    ../Drivers/STM32F3xx_HAL_Driver/Src/: stm32f3xx_hal.c stm32f3xx_hal_cortex.c stm32f3xx_hal_dma.c stm32f3xx_hal_exti.c stm32f3xx_hal_flash.c stm32f3xx_hal_flash_ex.c stm32f3xx_hal_gpio.c stm32f3xx_hal_i2c.c stm32f3xx_hal_i2c_ex.c stm32f3xx_hal_pwr.c stm32f3xx_hal_pwr_ex.c stm32f3xx_hal_rcc.c stm32f3xx_hal_rcc_ex.c stm32f3xx_hal_rtc.c stm32f3xx_hal_rtc_ex.c stm32f3xx_hal_tim.c stm32f3xx_hal_tim_ex.c
  group Application/User/Peripheral
    ../Src/: dimmer.c MAX31855.c timers.c
  group Drivers/STM32F3xx_HAL_Driver
    ../Drivers/STM32F3xx_HAL_Driver/Src/: stm32f3xx_hal_spi.c stm32f3xx_hal_spi_ex.c stm32f3xx_hal_uart.c stm32f3xx_hal_uart_ex.c
